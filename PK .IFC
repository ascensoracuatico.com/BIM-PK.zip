Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 00_Ensamblaje completo PK_BIM2026 SIN TORNILLOS ENSAM V1.IFC
Time: 2026-02-13T09:32:13
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Carcasa silla
In: Default Storey
Material: ABS
